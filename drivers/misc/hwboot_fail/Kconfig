## drivers/misc/hwboot_fail/Kconfig
```kconfig
config HWBOOT_FAIL
	tristate "record boot fail"
	depends on HUAWEI_KERNEL
	default n
	help
	  Say Y here to enable record boot fail
```
